# Keil uVision project STM32H723.uvprojx, settings and files
target STM32H723 (6110000::V6.11::.\ARMCLANG)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H723 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7,ARM_MATH_DSP,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\Drivers\User\Inc;..\FatFs;..\Drivers\CMSIS\DSP;..\Drivers\CMSIS\NN\Include;..\Drivers\CMSIS\NN\Include\Internal;..\Core\NNExamples
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/Core/NN-Example
    ../Core/NNExamples/: arm_nnexamples_cifar10_inputs.h arm_nnexamples_cifar10_parameter.h arm_nnexamples_cifar10_weights.h
  group Drivers/User
    ../Drivers/User/Src/: led.c usart.c sdmmc_sd.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Fatfs
    ../FatFs/: diskio.c ff.c ff_gen_drv.c ffunicode.c sd_diskio.c
  group Drivers/CMSIS-DSP
    ../Drivers/CMSIS/DSP/: arm_cortexM7lfdp_math.lib arm_common_tables.h arm_const_structs.h arm_math.h
  group Drivers/CMSIS-NN
    ../Drivers/CMSIS/NN/Include/: arm_nn_math_types.h arm_nn_tables.h arm_nn_types.h arm_nnfunctions.h arm_nnsupportfunctions.h
    ../Drivers/CMSIS/NN/Include/Internal/: arm_nn_compiler.h
    ../Drivers/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activation_s16.c arm_relu_q7.c arm_relu_q15.c arm_relu6_s8.c
    ../Drivers/CMSIS/NN/Source/BasicMathFunctions/: arm_elementwise_add_s8.c arm_elementwise_add_s16.c arm_elementwise_mul_acc_s16.c arm_elementwise_mul_s8.c arm_elementwise_mul_s16.c arm_elementwise_mul_s16_batch_offset.c arm_elementwise_mul_s16_s8.c
    ../Drivers/CMSIS/NN/Source/ConcatenationFunctions/: arm_concatenation_s8_w.c arm_concatenation_s8_x.c arm_concatenation_s8_y.c arm_concatenation_s8_z.c
    ../Drivers/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_1_x_n_s4.c arm_convolve_1_x_n_s8.c arm_convolve_1x1_s4.c arm_convolve_1x1_s4_fast.c arm_convolve_1x1_s8.c arm_convolve_1x1_s8_fast.c arm_convolve_get_buffer_sizes_s4.c arm_convolve_get_buffer_sizes_s8.c arm_convolve_get_buffer_sizes_s16.c arm_convolve_s4.c arm_convolve_s8.c arm_convolve_s16.c arm_convolve_wrapper_s4.c arm_convolve_wrapper_s8.c arm_convolve_wrapper_s16.c arm_depthwise_conv_3x3_s8.c arm_depthwise_conv_fast_s16.c arm_depthwise_conv_get_buffer_sizes_s4.c arm_depthwise_conv_get_buffer_sizes_s8.c arm_depthwise_conv_get_buffer_sizes_s16.c arm_depthwise_conv_s4.c arm_depthwise_conv_s4_opt.c arm_depthwise_conv_s8.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_s16.c arm_depthwise_conv_wrapper_s4.c arm_depthwise_conv_wrapper_s8.c arm_depthwise_conv_wrapper_s16.c arm_nn_depthwise_conv_s8_core.c arm_nn_mat_mult_kernel_row_offset_s8_s16.c arm_nn_mat_mult_kernel_s4_s16.c arm_nn_mat_mult_kernel_s8_s16.c arm_nn_mat_mult_kernel_s16.c arm_nn_mat_mult_s8.c arm_transpose_conv_get_buffer_sizes_s8.c arm_transpose_conv_s8.c
    ../Drivers/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_get_buffer_sizes_s8.c arm_fully_connected_get_buffer_sizes_s16.c arm_fully_connected_s4.c arm_fully_connected_s8.c arm_fully_connected_s16.c arm_vector_sum_s8.c arm_vector_sum_s8_s64.c
    ../Drivers/CMSIS/NN/Source/LSTMFunctions/: arm_lstm_unidirectional_s8.c arm_lstm_unidirectional_s16.c
    ../Drivers/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_depthwise_conv_nt_t_s4.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_depthwise_conv_nt_t_s16.c arm_nn_lstm_calculate_gate_s8_s16.c arm_nn_lstm_calculate_gate_s16.c arm_nn_lstm_step_s8.c arm_nn_lstm_step_s16.c arm_nn_mat_mul_core_1x_s4.c arm_nn_mat_mul_core_1x_s8.c arm_nn_mat_mul_core_4x_s8.c arm_nn_mat_mult_nt_t_s4.c arm_nn_mat_mult_nt_t_s8.c arm_nn_mat_mult_nt_t_s8_s32.c arm_nn_mat_mult_nt_t_s16.c arm_nn_vec_mat_mul_result_acc_s8_s16.c arm_nn_vec_mat_mul_result_acc_s16.c arm_nn_vec_mat_mult_t_s4.c arm_nn_vec_mat_mult_t_s8.c arm_nn_vec_mat_mult_t_s16.c arm_nn_vec_mat_mult_t_svdf_s8.c arm_nntables.c arm_q7_to_q15_with_offset.c arm_s8_to_s16_unordered_with_offset.c
    ../Drivers/CMSIS/NN/Source/PoolingFunctions/: arm_avgpool_get_buffer_sizes_s8.c arm_avgpool_get_buffer_sizes_s16.c arm_avgpool_s8.c arm_avgpool_s16.c arm_max_pool_s8.c arm_max_pool_s16.c
    ../Drivers/CMSIS/NN/Source/ReshapeFunctions/: arm_reshape_s8.c
    ../Drivers/CMSIS/NN/Source/SoftmaxFunctions/: arm_nn_softmax_common_s8.c arm_softmax_s8.c arm_softmax_s8_s16.c arm_softmax_s16.c arm_softmax_u8.c
    ../Drivers/CMSIS/NN/Source/SVDFunctions/: arm_svdf_get_buffer_sizes_s8.c arm_svdf_s8.c arm_svdf_state_s16_s8.c
software components: CMSIS:CORE 5.3.0
